LIST P=16F877A
INCLUDE "P16F877A.INC"
__config h'3F31'
DEGER EQU h'20'
ORG 0X00
CLRF PORTB
CLRF PORTA
BANKSEL TRISB
CLRF TRISB
MOVLW b'11111111'
MOVWF TRISA
MOVLW 0X06
MOVWF ADCON1
BANKSEL PORTB

MOVLW b'10101010'
MOVWF DEGER

BASLA

BTFSS PORTA,0
BTFSS PORTA,1
GOTO TERSLE
GOTO DUZELT

TERSLE
	COMF DEGER,1
	movf DEGER,0
	MOVWF PORTB
GOTO BASLA

DUZELT
	RLF DEGER,1
movf DEGER,0
MOVWF PORTB
GOTO BASLA
END